# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\bsp\key;..\bsp\LED;..\bsp\USART;..\bsp\Timer;..\bsp\SYSTIME;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\bsp\RTOS;..\bsp\Key;..\bsp\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h FreeRTOS.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group BSP
    ../bsp/LED/: bsp_led.c
    ../bsp/USART/: bsp_usart.c
    ../bsp/Timer/: bsp_timer.c
    ../bsp/RTOS/: bsp_rtos.c
    ../bsp/Key/: bsp_key.c
    ../bsp/PWM/: bsp_pwm.c
  group SYSTEM
    ../System/: system_f103.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
